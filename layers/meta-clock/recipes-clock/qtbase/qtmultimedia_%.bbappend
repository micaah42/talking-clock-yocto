PACKAGECONFIG = "ffmpeg pulseaudio qml"