# device utilities
RDEPENDS:packagegroup-qt6-addons:remove = "qtdeviceutilities"