FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SPLASH_IMAGES:forcevariable = "file://icon-boot-img.h;outsuffix=raspberrypi"
